ORG 0000H
RESULT EQU 10H
SEARCH EQU 20H
STORE EQU 50H

MOV DPTR, #NUMS
MOV R0,#STORE
MOV R3,#5

LOOP:
MOV A ,#0H
MOVC A,@A+DPTR
MOV @R0,A
INC R0
INC DPTR
DJNZ R3,LOOP

MOV R0,#STORE
MOV R3,#5

LOOP1:
MOV A,@R0
INC R0
DJNZ R3, CMP
CONT: SJMP CONT

CMP:
CJNE A,#SEARCH,LOOP1
MOV RESULT,#1
CONT1: SJMP CONT1

NUMS: DB 10H,20H,30H,40H,50H
END