# Keil uVision project sellingprice.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: sellingprice
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: selling.a51
